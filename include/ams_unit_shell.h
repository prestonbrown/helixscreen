// SPDX-License-Identifier: GPL-3.0-or-later

#pragma once

/**
 * @file ams_unit_shell.h
 * @brief The shape of a specific filament unit on the live spool tray.
 *
 * Lengths are pixels at a 110 px spool and scale with the real spool size.
 * The tables are generated by scripts/unit_art/build.py.
 */

#include <algorithm>
#include <cmath>
#include <cstdint>

namespace helix {
struct AmsSystemInfo;
}

namespace helix::ui::tray {

inline constexpr float kShellReferenceSpool = 110.0f;

/// One point of a side profile: depth 0 (front) to 1 (back), height above the front wall's top.
struct ProfilePoint {
    float depth_frac;
    float height_px;
};

/// Where a front part measures its x from.
enum class FrontAnchor : uint8_t { Span, Lane, Center, Left, Right };

/// One rectangle on a unit's front. Lengths are pixels at the reference spool; y runs down
/// from the front wall's top, and a negative y stands above it.
struct FrontPart {
    FrontAnchor anchor;
    float x0, x1;
    float y0, y1;
    uint32_t color;
    int radius;
};

/// How a sliding selector moves in its art for one gate count. The steps are fractions of
/// the art's displayed width per gate, measured from the baked position at gate 0.
struct CarriageTrack {
    int lanes;
    float step_x;
    float step_y;
    float aspect; ///< The art's width over its height.
};

/// A selector rail drawn head-on on the path screen, for one gate count. Positions are shares
/// of the art's width (x) and height (y); the carriage layer is baked at gate 0.
struct RailFaceArt {
    int lanes;
    float aspect;      ///< The art's width over its height.
    float gate0_x;     ///< Where gate 0's lane goes in.
    float gate_step_x; ///< From one gate's inlet to the next, and the carriage's travel per gate.
    float inlet_y;     ///< The height every lane goes in at.
    float outlet_x;    ///< Where the selected filament's tube leaves the art, carriage at gate 0.
    float outlet_y;
};

/// How a unit's lanes meet on the path screen.
enum class LaneJoin : uint8_t {
    Hub,        ///< A labelled hub box, or the selector bar of a LINEAR unit.
    Junction,   ///< Lanes leave the unit and meet at a small unlabelled junction.
    Inside,     ///< Lanes merge in the unit: a short merge below it, then one tube.
    FixedBlock, ///< A fixed selector block with one port per lane.
};

struct UnitShell {
    const char* id;
    const ProfilePoint* cheek;
    int cheek_n;
    const ProfilePoint* dome;
    int dome_n;
    int art_lanes;
    float back_extra_px;
    float front_wall_px;
    float cap_clearance_px;
    bool lid_spans_row;
    LaneJoin lane_join;
    uint32_t body;
    uint32_t corner; ///< Rear corner block colour; 0 when the unit has none.
    const FrontPart* front;
    int front_n;
    bool
        has_stub_art; ///< A second drawing, the body alone with a tube per lane, sits under stubs/.
    /// Bit n set: baked art exists for n lanes, in a folder of its own. 0: only art_lanes.
    uint32_t art_lane_variants = 0;
    const CarriageTrack* carriage = nullptr; ///< One row per baked gate count; nullptr for none.
    int carriage_n = 0;
    const RailFaceArt* face_art = nullptr; ///< One row per baked gate count; nullptr for none.
    int face_art_n = 0;
    /// A box per lane: each box's top is this solid colour around its glass. 0: all glass.
    uint32_t lid_color = 0;
    /// How far the unit's base reaches below its spools, at the reference spool size.
    float spool_lift_px = 0.0f;
};

/// The head-on art for a unit built with @p lanes gates, or nullptr.
inline const RailFaceArt* unit_shell_face_art(const UnitShell& shell, int lanes) {
    for (int i = 0; i < shell.face_art_n; ++i) {
        if (shell.face_art[i].lanes == lanes)
            return &shell.face_art[i];
    }
    return nullptr;
}

/// The carriage track for a unit built with @p lanes gates, or nullptr.
inline const CarriageTrack* unit_shell_carriage(const UnitShell& shell, int lanes) {
    for (int i = 0; i < shell.carriage_n; ++i) {
        if (shell.carriage[i].lanes == lanes)
            return &shell.carriage[i];
    }
    return nullptr;
}

struct CarriageOffset {
    int32_t x;
    int32_t y;
};

/// Where the carriage sits for @p gate, in pixels from gate 0, when the art is fitted into a
/// @p width x @p height box.
inline CarriageOffset carriage_offset(const CarriageTrack& track, int gate, int32_t width,
                                      int32_t height) {
    const float shown =
        std::min(static_cast<float>(width), static_cast<float>(height) * track.aspect);
    return {static_cast<int32_t>(std::lround(gate * track.step_x * shown)),
            static_cast<int32_t>(std::lround(gate * track.step_y * shown))};
}

/// Whether baked art exists for a unit built with @p lanes bays.
inline bool unit_shell_has_art_for(const UnitShell& shell, int lanes) {
    if (shell.art_lane_variants == 0)
        return lanes == shell.art_lanes;
    return lanes >= 0 && lanes < 32 && ((shell.art_lane_variants >> lanes) & 1u) != 0;
}

/// The generated shell named @p id, or nullptr.
const UnitShell* unit_shell_by_id(const char* id);

/// The shell for one unit, or nullptr to keep the generic tray. @p has_dryer joins the unit's
/// own climate readings as evidence that an optionally enclosed unit has its enclosure.
const UnitShell* unit_shell_for(const AmsSystemInfo& info, int unit_index, bool has_dryer = false);

} // namespace helix::ui::tray
