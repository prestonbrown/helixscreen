// SPDX-License-Identifier: GPL-3.0-or-later

#pragma once

/**
 * @file ams_unit_shell.h
 * @brief The shape of a specific filament unit on the live spool tray.
 *
 * Lengths are pixels at a 110 px spool and scale with the real spool size.
 * The tables are generated by scripts/unit_art/build.py.
 */

#include <algorithm>
#include <cmath>
#include <cstdint>
#include <vector>

namespace helix {
struct AmsSystemInfo;
}

namespace helix::ui::tray {

inline constexpr float kShellReferenceSpool = 110.0f;

/// One point of a side profile: depth 0 (front) to 1 (back), height above the front wall's top.
struct ProfilePoint {
    float depth_frac;
    float height_px;
};

/// Where a front part measures its x from.
enum class FrontAnchor : uint8_t { Span, Lane, Center, Left, Right };

/// One rectangle on a unit's front. Lengths are pixels at the reference spool; y runs down
/// from the front wall's top, and a negative y stands above it.
struct FrontPart {
    FrontAnchor anchor;
    float x0, x1;
    float y0, y1;
    uint32_t color;
    int radius;
};

/// How a sliding selector moves in its art for one gate count. The steps are fractions of
/// the art's displayed width per gate, measured from the baked position at gate 0.
struct CarriageTrack {
    int lanes;
    float step_x;
    float step_y;
    float aspect; ///< The art's width over its height.
};

/// A selector rail drawn head-on on the path screen, for one gate count. Positions are shares
/// of the art's width (x) and height (y); the carriage layer is baked at gate 0.
struct RailFaceArt {
    int lanes;
    float aspect;      ///< The art's width over its height.
    float gate0_x;     ///< Where gate 0's lane goes in.
    float gate_step_x; ///< From one gate's inlet to the next, and the carriage's travel per gate.
    float inlet_y;     ///< The height every lane goes in at.
    float outlet_x;    ///< Where the selected filament's tube leaves the art, carriage at gate 0.
    float outlet_y;
};

/// Where a unit's lanes merge into the one output that feeds a single extruder
/// (docs/devel/UNIT_ART.md § "Combiner").
enum class Combiner : uint8_t {
    Absent,   ///< One lane: nothing to merge.
    Internal, ///< Inside the unit: one path leaves it.
    External, ///< A separate hub below the unit: each lane leaves by its own outlet into it.
};

struct UnitShell {
    const char* id;
    const ProfilePoint* cheek;
    int cheek_n;
    const ProfilePoint* dome;
    int dome_n;
    int art_lanes;
    float back_extra_px;
    float front_wall_px;
    float cap_clearance_px;
    bool lid_spans_row;
    Combiner combiner;
    bool port_block; ///< Its selector is a fixed block with one port per lane.
    uint32_t body;
    uint32_t corner; ///< Rear corner block colour; 0 when the unit has none.
    const FrontPart* front;
    int front_n;
    bool
        has_stub_art; ///< A second drawing, the body alone with a tube per lane, sits under stubs/.
    /// Bit n set: baked art exists for n lanes, in a folder of its own. 0: only art_lanes.
    uint32_t art_lane_variants = 0;
    const CarriageTrack* carriage = nullptr; ///< One row per baked gate count; nullptr for none.
    int carriage_n = 0;
    const RailFaceArt* face_art = nullptr; ///< One row per baked gate count; nullptr for none.
    int face_art_n = 0;
    /// A box per lane: each box's top is this solid colour around its glass. 0: all glass.
    uint32_t lid_color = 0;
    /// How far the unit's base reaches below its spools, at the reference spool size.
    float spool_lift_px = 0.0f;
    /// The unit stands in front of loose spools, so the tray under them is the plain one.
    bool plain_tray = false;
};

/// The head-on art for a unit built with @p lanes gates, or nullptr.
inline const RailFaceArt* unit_shell_face_art(const UnitShell& shell, int lanes) {
    for (int i = 0; i < shell.face_art_n; ++i) {
        if (shell.face_art[i].lanes == lanes)
            return &shell.face_art[i];
    }
    return nullptr;
}

/// The carriage track for a unit built with @p lanes gates, or nullptr.
inline const CarriageTrack* unit_shell_carriage(const UnitShell& shell, int lanes) {
    for (int i = 0; i < shell.carriage_n; ++i) {
        if (shell.carriage[i].lanes == lanes)
            return &shell.carriage[i];
    }
    return nullptr;
}

struct CarriageOffset {
    int32_t x;
    int32_t y;
};

/// Where the carriage sits for @p gate, in pixels from gate 0, when the art is fitted into a
/// @p width x @p height box.
inline CarriageOffset carriage_offset(const CarriageTrack& track, int gate, int32_t width,
                                      int32_t height) {
    const float shown =
        std::min(static_cast<float>(width), static_cast<float>(height) * track.aspect);
    return {static_cast<int32_t>(std::lround(gate * track.step_x * shown)),
            static_cast<int32_t>(std::lround(gate * track.step_y * shown))};
}

/// Whether baked art exists for a unit built with @p lanes bays.
inline bool unit_shell_has_art_for(const UnitShell& shell, int lanes) {
    if (shell.art_lane_variants == 0)
        return lanes == shell.art_lanes;
    return lanes >= 0 && lanes < 32 && ((shell.art_lane_variants >> lanes) & 1u) != 0;
}

/// The generated shell named @p id, or nullptr.
const UnitShell* unit_shell_by_id(const char* id);

/// One lane of a baked unit drawing, in shares of the drawing's width from its top-left
/// corner (scripts/unit_art/build.py#LaneGeometry). The spool is every disc of radius 1 in the
/// basis (ey, ez) between the flange centers far and near; wound and core are the full
/// filament's and the core's radii in that unit. box bounds the flange's cylinder, and outlet
/// is where the lane's filament leaves the unit.
struct ArtLaneGeom {
    float far_x, far_y, near_x, near_y;
    float ey_x, ey_y, ez_x, ez_y;
    float wound, core;
    float box_x0, box_y0, box_x1, box_y1;
    float outlet_x, outlet_y;
    /// The lane's prep sensor as drawn: prep_n corners (x, y in turn), 0 where it is not drawn.
    float prep[16] = {};
    int prep_n = 0;
};

/// A unit drawing's lanes at one lane count: its aspect (width over height), what the drawing
/// covers, its bottom edge, and one ArtLaneGeom per lane.
/// The most lanes one drawing is baked with.
constexpr int kMaxArtLanes = 8;

struct UnitArtGeom {
    const char* id;
    int lanes;
    float aspect;
    float drawn[4];       // x0, y0, x1, y1
    float bottom_edge[4]; // the unit's front bottom edge as drawn: x0, y0, x1, y1
    const ArtLaneGeom* lane;
    /// Every lane bakes its near flange's face apart (`laneN_face`) and the drawing has one set
    /// of vents (`vents`, `vents_lit`), so a feeding spool can turn them.
    bool spins = false;
    /// Its lanes' stacks hold parts besides their spools, so a dim lays each spool's own baked
    /// silhouette over its stack instead of recoloring the stack.
    bool silhouettes = false;
    /// The lanes in the order the drawing paints their stacks, back to front; the runtime
    /// composes them in this order. Unset (all zero) means the lanes' own numbering.
    uint8_t order[kMaxArtLanes] = {};

    /// The lane painted at position @p pos of the back-to-front order.
    [[nodiscard]] int lane_at(int pos) const {
        // A permutation of more than one lane is never all zero, so all zero is unset.
        const bool numbered = std::all_of(order, order + std::min(lanes, kMaxArtLanes),
                                          [](uint8_t lane) { return lane == 0; });
        return numbered || pos < 0 || pos >= kMaxArtLanes ? pos : order[pos];
    }
};

/// The baked lane geometry of @p id's drawing at @p lanes lanes, or nullptr when it has none.
const UnitArtGeom* unit_art_geometry(const char* id, int lanes);

/// The shell for one unit, or nullptr to keep the generic tray. @p has_dryer joins the unit's
/// own climate readings as evidence that an optionally enclosed unit has its enclosure.
const UnitShell* unit_shell_for(const AmsSystemInfo& info, int unit_index, bool has_dryer = false);

/// A drawing and the units whose bays it shows, in order.
struct DeviceShell {
    const UnitShell* shell = nullptr;
    std::vector<int> unit_indices;
};

/// The drawing of the whole device unit @p unit_index belongs to. A backend can report one
/// device as several units, each drawn as its slice of it: such a unit gets the device's
/// drawing and every unit that makes it up. Any other unit gets its own shell.
DeviceShell device_shell_for(const AmsSystemInfo& info, int unit_index, bool has_dryer = false);

} // namespace helix::ui::tray
